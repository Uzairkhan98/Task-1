# Keil uVision project proj_New.uvprojx, settings and files
target proj_New (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: proj_New
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Nuvoton\NUC140BSP_EDU\Library\CMSIS\Include;C:\Nuvoton\NUC140BSP_EDU\Library\Device\Nuvoton\NUC1xx\Include;C:\Nuvoton\NUC140BSP_EDU\Library\Device\Nuvoton\NUC1xx\Source;C:\Nuvoton\NUC140BSP_EDU\Library\;C:\Nuvoton\NUC140BSP_EDU\Library\NUC1xx\Include;C:\Nuvoton\NUC140BSP_EDU\Library\NUC1xx-LB_002\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS Group
    C:/Nuvoton/NUC140BSP_EDU/Library/CMSIS/Include/: core_cm0.c
    C:/Nuvoton/NUC140BSP_EDU/Library/Device/Nuvoton/NUC1xx/Source/: system_NUC1xx.c
    C:/Nuvoton/NUC140BSP_EDU/Library/Device/Nuvoton/NUC1xx/Source/arm/: startup_NUC1xx.s
  group Source Group
    C:/Nuvoton/NUC140BSP_EDU/Library/NUC1xx-LB_002/Source/: LCD.c Scankey.c Seven_Segment.c 2DGraphics.c
    ../: main.c
  group Library Group
    C:/Nuvoton/NUC140BSP_EDU/Library/NUC1xx/Source/: GPIO.c SYS.c SPI.c
